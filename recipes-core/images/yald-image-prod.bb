require recipes-core/images/core-image-minimal.bb

ENABLE_UART:raspberrypi3-64 = "1"
